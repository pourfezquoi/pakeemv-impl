# Keil uVision project HSCTU_SCard_Demo.uvprojx, settings and files
target Debug (6220000::V6.22::ARMCLANG)
  device: ARMSC300 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("SC300") CLOCK(12000000) ESEL ELITTLE
  output: HSCTU_SCard_Demo
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PAKE_EMV_BENCHMARK=1,PAKE_EMV_SYSTICK_BENCHMARK=1
  c include: .\Demo;.\Library;.\Source;.\ml-kem\h;.\aes\h
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1e000
  group Startup
    ./Source/: startup_HSC300.s
  group Demo
    ./Demo/: main.c smartcard_demo.c
    ./aes/h/: aes_gcm.h
    ./aes/c/: aes_gcm.c
  group Source
    ./Source/: sci.c
  group Library (Board Support)
    ./Library/: clockset_v101.lib flash_v103.lib pad_Init_v104.lib
  group Library (ML-KEM Dependencies)
    ./ml-kem/c/: trng_v100.lib hash_v101.lib
  group Library (AES Dependencies)
    ./aes/c/: Sym_Alg_v101.lib
  group ml-kem
    ./ml-kem/c/: cbd.c fips202.c gpio.c indcpa.c kem.c ntt.c poly.c polyvec.c randombytes.c reduce.c symmetric-shake.c systick.c verify.c
